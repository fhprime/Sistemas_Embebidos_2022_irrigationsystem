# Keil uVision project Proyecto Sistemas Embebidos FH.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proyecto Sistemas Embebidos FH
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\AppData\Local\Arm\Packs\Keil\STM32F3xx_DFP\2.1.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include\;..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include\;.\;C:\Keil_v5\ARM\SFD\Dialog\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Drivers
    ./: drivers.c drivers.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
